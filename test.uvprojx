# Keil uVision project test.uvprojx, settings and files
target GC1_Test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ENS_iftsine_TEST +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORTEX_M0
  c include: .\common\cmsis\CMSIS\Include;.\common\cmsis\Device\ARM\CMSDK_CM0\Include;.\common\retarget;.\source
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./source/: main.c boost_select.c
  group StartUp
    ./common/cmsis/Device/ARM/CMSDK_CM0/Source/ARM/: startup_CMSDK_CM0.s
  group Device
    ./common/cmsis/Device/ARM/CMSDK_CM0/Source/: CMSDK_driver.c system_CMSDK_CM0.c
    ./common/retarget/: uart_stdout.c retarget.c
software components: CMSIS:CORE 4.3.0
